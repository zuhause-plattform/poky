inherit setuptools3
require python-mako.inc
DPENDS += "python3-setuptools"